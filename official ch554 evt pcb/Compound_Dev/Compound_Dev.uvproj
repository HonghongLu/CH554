# Keil uVision project Compound_Dev.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Compound_Dev +hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: Compound.C main.c README.TXT
    ./Touch_Key/: Touch_Key.C
    ./Public/: DEBUG.C
